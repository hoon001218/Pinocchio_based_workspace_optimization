Commit message: checkpoint

File: assets/robots/sr12ia/sr12ia_approx.urdf (robot description, URDF)
Before this commit: robot fanuc_sr12ia_approx, 8 links, 7 joints
Links:
- removed link cutter_proxy
Joints:
- removed joint tool0-provisional-cutter
